# Keil uVision project TV_720x480.uvproj, settings and files
target N3290_TV_720x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N3290_VPOST_TV_D1 (library)
  AfterMake: N3290_TV_720x480.bat
  c flags: Optim=1 wLevel=2
  c define: __HAVE_TVOUT_720x480__
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: N3290_VPOST.C N3290_VPOST_Driver.c N3290_VPOST_TVOUT_D1_720x480.c
