# Keil uVision project TV_640x480.uvproj, settings and files
target TV_640x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: TV_640x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_640x480__,__TV_OUTPUT__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../Src/: main_vpost.c standalone.c wb_init.s
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../Lib/: W55FA93_VPOST_TV_VGA.lib
