# Keil uVision project FW050TFT_800x480.uvproj, settings and files
target N32905_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: FW050TFT_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_800x480__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../Src/: main_vpost.c standalone.c wb_init.s
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../Lib/: W55FA93_VPOST_FW050TFT_800x480.lib
target N32903_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: FW050TFT_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_800x480__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go
target N32901_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: FW050TFT_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_800x480__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
