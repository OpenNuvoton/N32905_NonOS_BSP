# Keil uVision project Video_Class_Demo.uvproj, settings and files
target Vin_Format_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: ..\..\..\..\lib;..\..\..\..\..\gpio\lib;..\..\..\..\..\JPEG\LIB;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\VideoIn\Lib;..\..\..\..\..\gnand\Lib;..\..\..\..\..\NVTFAT\lib;..\..\..\..\..\SIC\Lib;..\..\I2CS;..\..\GM7150
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../../: demo.c GCD.c Smpl_FSC_NT99050.c Smpl_FSC_Ov7670.c Smpl_FSC_Ov7725.c Smpl_I2C.c standalone.c uvc_main.c wb_init.s Smpl_FSC_GC0308.c Smpl_FSC_GM7150.c Smpl_FSC_TVP5150.c demo_wakeup.c Smpl_FSC_NT99141.c
    ../../../../../gpio/lib/: w55fa93_gpio.lib
    ../../../../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../lib/: w55fa93_UDC.lib w55fa93_UVC.lib w55fa93_UVC_YUV_Only.lib w55fa93_UVC_MJPEG_Only.lib
    ../../../../../VideoIn/Lib/: W55FA93_VideoIn.lib
    ../../I2CS/: DrvI2C.c
target Fixed_Format_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
