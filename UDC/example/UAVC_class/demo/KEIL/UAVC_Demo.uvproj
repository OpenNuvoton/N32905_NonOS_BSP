# Keil uVision project UAVC_Demo.uvproj, settings and files
target N32903_Vin_Format_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: UAVC_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: ..\..\..\..\lib;..\..\I2CS;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\adc\lib;..\..\..\..\..\gpio\lib;..\..\..\..\..\JPEG\LIB;..\..\..\..\..\VideoIn\Lib;..\..\..\..\..\EDMA\lib;..\..\..\..\src\UAVC
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../: adc.c demo.c GCD.c Smpl_FSC_NT99050.c Smpl_FSC_Ov7670.c Smpl_FSC_Ov7725.c Smpl_I2C.c standalone.c uavc_main.c wb_init.s
    ../../I2CS/: DrvI2C.c
    ../../../../lib/: w55fa93_UDC.lib w55fa93_UAVC_YUV_Only.lib w55fa93_UAVC.lib w55fa93_UAVC_MJPEG_Only.lib
    ../../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../../adc/lib/: W55FA93_adc_Int.lib
    ../../../../../gpio/lib/: w55fa93_gpio.lib
    ../../../../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../../../../VideoIn/Lib/: W55FA93_VideoIn.lib
    ../../../../../EDMA/lib/: w55fa93_edma.lib
target N32903_Vin_Format_YUV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32903_Vin_Format_MJPEG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32901_Vin_Format_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32901_Vin_Format_YUV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32901_Vin_Format_MJPEG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: UAVC_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
