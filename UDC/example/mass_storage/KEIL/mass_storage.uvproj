# Keil uVision project mass_storage.uvproj, settings and files
target RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_ONLY__
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\SIC\Lib;..\..\..\..\gnand\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c wb_init.s demo_wakeup.c
    ../../../lib/: w55fa93_MSC_ALL_SD_PORT0.lib w55fa93_MSC_ALL_SD_PORT1.lib w55fa93_MSC_ALL_SD_MP_PORT1.lib w55fa93_MSC_ALL_SD_MP_PORT0.lib w55fa93_MSC_RAM.lib w55fa93_MSC_NAND.lib w55fa93_MSC_SD_PORT0.lib w55fa93_MSC_SD_PORT1.lib w55fa93_MSC_SD_PORT2.lib w55fa93_MSC_SD_MP_PORT0.lib w55fa93_MSC_SD_MP_PORT1.lib w55fa93_MSC_SD_MP_PORT2.lib w55fa93_UDC.lib w55fa93_MSC_SPI.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../gnand/Lib/: w55fa93_GNAND.lib
    ../../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../../SPI/Lib/: w55fa93_SPI.lib
    ../../../../gpio/lib/: w55fa93_gpio.lib
target NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
