# Keil uVision project VirtualCom.uvproj, settings and files
target N32906 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry Reset_Go
  group Source Group
    ../: main.c standalone.c wb_init.s demo_wakeup.c
    ../../../../gpio/lib/: n3290_gpio.lib
  group Library Group
    ../: VirtualCom.c
    ../../../lib/: n3290_UDC.lib
    ../../../../SYSLIB/Lib/: N3290_syslib.lib
target N32905 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go
target N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
