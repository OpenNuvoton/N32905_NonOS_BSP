# Keil uVision project UAVC_Demo.uvproj, settings and files
target N32906_Vin_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_Vin_Format_BOTH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: ..\..\..\..\lib;..\..\I2CS;..\..\..\..\..\SYSLIB\Lib;..\..\..\..\..\adc\lib;..\..\..\..\..\gpio\lib;..\..\..\..\..\JPEG\LIB;..\..\..\..\..\VideoIn\Lib;..\..\..\..\..\EDMA\lib;..\..\..\..\src\UAVC
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32906\N32906.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../: adc.c demo.c GCD.c Smpl_FSC_NT99050.c Smpl_FSC_Ov7670.c Smpl_FSC_Ov7725.c Smpl_I2C.c standalone.c uavc_main.c wb_init.s demo_wakeup.c
    ../../I2CS/: DrvI2C.c
    ../../../../lib/: n3290_UDC.lib n3290_UAVC_YUV_Only.lib n3290_UAVC.lib n3290_UAVC_MJPEG_Only.lib
    ../../../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../../../adc/lib/: N3290_adc_Int.lib
    ../../../../../gpio/lib/: n3290_gpio.lib
    ../../../../../JPEG/LIB/: n3290_jpeglib.lib
    ../../../../../VideoIn/Lib/: N3290_VideoIn.lib
    ../../../../../EDMA/lib/: n3290_edma.lib
target N32905_Vin_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Vin_Format_BOTH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32903_Vin_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Vin_Format_BOTH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go
target N32901_Vin_BOTH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Vin_Format_BOTH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
target N32906_Vin_MJPEG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Vin_Format_MJPEG
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32906\N32906.sct
  link misc: --entry Reset_Go
target N32905_Vin_MJPEG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Vin_Format_MJPEG
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32903_Vin_MJPEG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Vin_Format_MJPEG
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go
target N32901_Vin_MJPEG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Vin_Format_MJPEG
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
target N32906_Vin_YUV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Vin_Format_YUV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32906\N32906.sct
  link misc: --entry Reset_Go
target N32905_Vin_YUV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Vin_Format_YUV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32905\N32905.sct
  link misc: --entry Reset_Go
target N32903_Vin_YUV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Vin_Format_YUV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go
target N32901_Vin_YUV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Vin_Format_YUV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __3RD_PORT__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
