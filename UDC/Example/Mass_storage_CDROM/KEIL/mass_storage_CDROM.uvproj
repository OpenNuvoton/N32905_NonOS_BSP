# Keil uVision project mass_storage_CDROM.uvproj, settings and files
target N32906_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gnand\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SIC\Lib;..\..\..\..\gpio\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c wb_init.s demo_wakeup.c
    ../../../lib/: n3290_MSC_CDROM_Only.lib n3290_MSC_RAM_CDROM.lib n3290_MSC_NAND_CDROM.lib n3290_MSC_SD_PORT0_CDROM.lib n3290_MSC_SD_PORT1_CDROM.lib n3290_MSC_SD_PORT2_CDROM.lib n3290_MSC_SD_MP_PORT0_CDROM.lib n3290_MSC_SD_MP_PORT1_CDROM.lib n3290_MSC_SD_MP_PORT2_CDROM.lib n3290_MSC_ALL_SD_PORT0_CDROM.lib n3290_MSC_ALL_SD_PORT1_CDROM.lib n3290_MSC_ALL_SD_MP_PORT0_CDROM.lib n3290_MSC_ALL_SD_MP_PORT1_CDROM.lib n3290_UDC.lib n3290_MSC_SPI_CDROM.lib
    ../../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../../gnand/Lib/: n3290_GNAND.lib
    ../../../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../../../SIC/Lib/: N3290_SIC.lib
    ../../../../SPI/Lib/: n3290_SPI.lib
    ../../../../gpio/lib/: n3290_gpio.lib
target N32905_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_All_Storage_SD_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_All_Storage_SD_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_All_Storage_SD_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_All_Storage_SD_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_All_Storage_SD_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_All_Storage_SD_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_All_Storage_SD_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_All_Storage_SD_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_All_Storage_SD_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_All_Storage_SD_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_All_Storage_SD_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_All_Storage_SD_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_All_Storage_SD_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_All_Storage_SD_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_All_Storage_SD_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_All_Storage_SD_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_All_Storage_SD_M_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_All_Storage_SD_M_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_All_Storage_SD_M_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_All_Storage_SD_M_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_All_Storage_SD_M_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_All_Storage_SD_M_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_All_Storage_SD_M_P0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_All_Storage_SD_M_P0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_All_Storage_SD_M_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_All_Storage_SD_M_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_All_Storage_SD_M_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_All_Storage_SD_M_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_All_Storage_SD_M_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_All_Storage_SD_M_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_All_Storage_SD_M_P1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_All_Storage_SD_M_P1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
