# Keil uVision project dev_spi.uvproj, settings and files
target Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N3290_SPI (library)
  AfterMake: Release.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: spi.c spiflash.c SPIGlue.c spiflash_freertos.c
target DebugRel_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N3290_SPI_FreeRTOS (library)
  AfterMake: DebugRel_FreeRTOS.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FreeRTOS__ __RAK439__
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib;..\..\..\FreeRTOS\Source\portable\RVDS\ARM9_N329x;..\..\..\FreeRTOS\Source\include
  memory RVCT9: RAM 0xf8002000 size 0x8000
