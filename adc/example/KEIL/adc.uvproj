# Keil uVision project adc.uvproj, settings and files
target AudioRecord (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\gnand\Lib;..\..\..\NVTFAT\lib;..\..\..\EDMA\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: adc.c audioRecord.c standalone.c TouchPanel.c wb_init.s
    ../../lib/: W55FA93_adc_Int.lib W55FA93_adc_Poll.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../gnand/Lib/: w55fa93_GNAND.lib
    ../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../EDMA/lib/: w55fa93_edma.lib
target block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _ADC_NONBLOCK_
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target block_polling (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target nonblock_polling (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _ADC_NONBLOCK_
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target Touch_WakeUp (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
