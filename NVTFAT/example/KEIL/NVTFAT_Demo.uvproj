# Keil uVision project NVTFAT_Demo.uvproj, settings and files
target FAT_NAND_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_GNAND
  c include: ..\..\lib;..\..\..\SIC\Lib;..\..\..\SYSLIB\Lib;..\..\..\gnand\Lib;..\..\..\USB_Core\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: Demo_CommandShell.c NVTFAT_ERROR.C RAMDiskDriver.c standalone.c wb_init.s
    ../../lib/: W55FA93_nvtfat.lib
    ../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../gnand/Lib/: w55fa93_GNAND.lib
    ../../../USB_Core/lib/: W55FA93_usbh.lib
target FAT_SD_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_SD ENABLE_SD_ONE_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target FAT_SD_TWO_PART (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_SD_TWO_PART ENABLE_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target FAT_SD_FOUR_PART (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_SD_FOUR_PART ENABLE_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target FAT_USBH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_USB_HOST
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target FAT_RAM_SD_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_RAM ENABLE_SD ENABLE_SD_ONE_PART
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
