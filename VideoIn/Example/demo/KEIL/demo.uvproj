# Keil uVision project demo.uvproj, settings and files
target N32906_Vin_1stP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_Vin_1stP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __1ST_PORT__ __HMI_BOARD__
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib;..\..\..\..\SIC\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\VPOST\Lib;..\..\..\..\gnand\Lib;..\..\I2CS
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../../: demo.c GCD.c Smpl_FSC_NT99050.c Smpl_FSC_NT99140.c Smpl_FSC_NT99141.c Smpl_FSC_Ov7670.c Smpl_FSC_Ov7725.c Smpl_FSC_Ov9660.c Smpl_FSC_GC0308.c Smpl_I2C.c Smpl_VPOST.c Smpl_WT8861.c standalone.c wb_init.s Smpl_FSC_TVP5150.c Smpl_FSC_GM7150.c Smpl_FSC_TW9900.c Smpl_FSC_GC032A.c
    ../../../Lib/: N3290_VideoIn.lib
    ../../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../../gpio/lib/: n3290_gpio.lib
    ../../../../SIC/Lib/: N3290_SIC.lib
    ../../../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../../../VPOST/Lib/: N3290_VPOST_GIANTPLUS_GPM1006.lib N3290_VPOST_GWMTF9360A.lib
    ../../../../gnand/Lib/: n3290_GNAND.lib
    ../../I2CS/: DrvI2C.c
target N32905_Vin_1stP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Vin_1stP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __1ST_PORT__ __HMI_BOARD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32906_Vin_2ndP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Vin_2ndP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_Vin_2ndP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Vin_2ndP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_Vin_2ndP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Vin_2ndP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_Vin_2ndP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Vin_2ndP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_Vin_3rdP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Vin_3rdP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __3RD_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_Vin_3rdP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Vin_3rdP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __3RD_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_Vin_3rdP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Vin_3rdP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __3RD_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_Vin_3rdP (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Vin_3rdP_GaintPlus_8Bit
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __3RD_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
