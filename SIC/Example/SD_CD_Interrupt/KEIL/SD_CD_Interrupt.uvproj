# Keil uVision project SD_CD_Interrupt.uvproj, settings and files
target N32906 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SD_CD_Interrupt
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\gnand\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SYSLIB\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../../Src/: standalone.c wb_init.s
    ../../../Lib/: N3290_SIC.lib
    ../../../../gnand/Lib/: n3290_GNAND.lib
    ../../../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../../../SYSLIB/Lib/: N3290_syslib.lib
    ../: main.c
target N32905 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SD_CD_Interrupt
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SD_CD_Interrupt
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SD_CD_Interrupt
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
