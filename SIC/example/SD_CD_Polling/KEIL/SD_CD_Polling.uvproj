# Keil uVision project SD_CD_Polling.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SD_CD_Polling
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\gnand\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../../Src/: standalone.c wb_init.s
    ../../../Lib/: W55FA93_SIC.lib
    ../../../../gnand/Lib/: w55fa93_GNAND.lib
    ../../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../: main.c
