# Keil uVision project fa93_jpegdemo.uvproj, settings and files
target JPEG_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: fa93_jpegdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib;..\..\..\..\gnand\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\VPOST\Lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c wb_init.s
    ../../: common.c jpegDec.c jpegEnc.c main.c
    ../../../LIB/: w55fa93_jpeglib.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST.lib
    ../../../../SIC/Lib/: W55FA93_SIC.lib
