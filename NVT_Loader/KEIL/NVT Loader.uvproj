# Keil uVision project NVT Loader.uvproj, settings and files
target N32906_NAND_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_800x600__ N32906=1
  c include: ..\inc;..\..\AVI\Lib;..\..\VPOST\Lib;..\..\adc\lib;..\..\RTC\LIB;..\..\Font\Lib;..\..\gnand\Lib;..\..\gpio\lib;..\..\JPEG\LIB;..\..\kpi\lib;..\..\UDC\lib;..\..\NVTFAT\lib;..\..\SIC\Lib;..\..\SPU\lib;..\..\SYSLIB\Lib;..\..\USB_Core\lib;..\..\SPI\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32906.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../NVT_Loader/src/: avi.c heap.s main.c mass.c NVT_BatteryDect.c stack.s standalone.c vectors.s wb_init.s
    ../../AVI/Lib/: N3290_AVILib.lib ima_adpcm_codec.lib mp3lib.lib
    ../../VPOST/Lib/: N3290_VPOST_GW07000TNWV.lib N3290_VPOST_AMPIRE_800x480.lib N3290_VPOST_AMPIRE_800x600.lib N3290_VPOST_GW9406A.lib N3290_VPOST_GWGW8973.lib N3290_VPOST_TIANMA_TM022HDH31.lib N3290_VPOST_GWMTF9360A.lib N3290_VPOST_GWMTF9615A.lib N3290_VPOST_HannStar.lib N3290_VPOST_HannStar_800x480.lib N3290_VPOST_Sharp.lib N3290_VPOST_TV_VGA.lib N3290_VPOST_Wintek_WMF3324.lib N3290_VPOST_SITRONIX.lib N3290_VPOST_GIANTPLUS_GPM1006.lib N3290_VPOST_HIMAX_HX8352.lib N3290_VPOST_HIMAX_HX8352_START.lib
    ../../adc/lib/: N3290_adc_Poll.lib
    ../../RTC/LIB/: n3290_RTClib.lib
    ../../Font/Lib/: N3290_font_QVGA.lib N3290_font_SVGA.lib N3290_font_WSVGA.lib
    ../../gnand/Lib/: n3290_GNAND.lib
    ../../gpio/lib/: n3290_gpio.lib
    ../../JPEG/LIB/: n3290_jpeglib.lib
    ../../kpi/lib/: n3290_kpi.lib n3290_kpi_1x4.lib n3290_kpi_2x3.lib n3290_kpi_2x2.lib
    ../../UDC/lib/: n3290_MSC_NAND.lib n3290_MSC_SD_MP_PORT0.lib n3290_UDC.lib
    ../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../SIC/Lib/: N3290_SIC.lib
    ../../SPU/lib/: n3290_spu.lib
    ../../SYSLIB/Lib/: N3290_syslib.lib
    ../../SPI/Lib/: N3290_SPI.lib
    ../../NVT_Loader/production/: EMU_ADC.c EMU_Draw.c EMU_Font.c EMU_KPD.c EMU_Memory.c EMU_NandFlash.c EMU_Production.c EMU_SdCard.c EMU_SPU.c EMU_USB_MassStorage.c EMU_USBH.c EMU_Vpost.c
target N32905_NAND_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_800x600__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32905.scf
  link misc: --entry Reset_Go
target N32906_NAND_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_NAND_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32905.scf
  link misc: --entry Reset_Go
target N32903_NAND_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_NAND_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_SD_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_800x600__ __ENABLE_SD_CARD_0__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_SD_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_800x600__ __ENABLE_SD_CARD_0__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32905.scf
  link misc: --entry Reset_Go
target N32906_SD_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ __ENABLE_SD_CARD_0__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_SD_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ __ENABLE_SD_CARD_0__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32905.scf
  link misc: --entry Reset_Go
target N32903_SD_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ __ENABLE_SD_CARD_0__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_SD_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ __ENABLE_SD_CARD_0__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_SPI_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_800x600__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_SPI_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_800x600__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32905.scf
  link misc: --entry Reset_Go
target N32906_SPI_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_SPI_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT_Loader\src\scat_N32905.scf
  link misc: --entry Reset_Go
