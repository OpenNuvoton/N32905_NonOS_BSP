# Keil uVision project fa93_RTCdemo.uvproj, settings and files
target N32905_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: fa93_RTCdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c wb_init.s
    ../../: main.c powercontrol.c
    ../../../LIB/: w55fa93_RTClib.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
target N32903_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: fa93_RTCdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: fa93_RTCdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
