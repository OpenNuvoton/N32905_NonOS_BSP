# Keil uVision project I2S_example.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: I2S_example
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\I2C\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../Src/: I2S_example.c standalone.c w55fa93_nau8822.c wb_init.s
    ../../lib/: w55fa93_i2s.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../I2C/lib/: w55fa93_i2c.lib
