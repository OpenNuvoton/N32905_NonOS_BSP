# Keil uVision project NVTFAT_FreeRTOS.uvproj, settings and files
target N32906_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_RTOS_NVTFAT_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\Startup;..\..\..\Source\portable\RVDS\ARM9_N329x;..\..\..\Source\include;..\..\Common\include;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\Lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib
  asm define: N32906
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Startup
    ../Startup/: wb_init.s standalone.c multithread.c main.c
  group Lib
    ../../../../SYSLIB/Lib/: N3290_SYSLib_FreeRTOS.lib
    ../../../../NVTFAT/Lib/: N3290_NVTFAT_FreeRTOS.lib
    ../../../../SIC/Lib/: N3290_SIC.lib
    ../../../../GNAND/Lib/: N3290_GNAND.lib
  group FreeRTOS
    ../../../Source/: tasks.c list.c queue.c
    ../../../Source/portable/MemMang/: heap_2.c
    ../../../Source/portable/RVDS/ARM9_N329x/: port.c portASM.s
target N32905_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_RTOS_NVTFAT_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32905
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_RTOS_NVTFAT_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32903
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_RTOS_NVTFAT_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_RTOS_NVTFAT_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N32906
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_RTOS_NVTFAT_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N32905
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_RTOS_NVTFAT_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N32903
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_RTOS_NVTFAT_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N32901
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
