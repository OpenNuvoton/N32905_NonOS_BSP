# Keil uVision project NandWriter.uvproj, settings and files
target N32906_NandWriter_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\gnand\Lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib;..\..\..\gpio\lib;..\..\..\Font\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../../Src/: DrawFont.c nvtNandDrv.c ProcessIni.c ProcessOptionalIni.c standalone.c wb_init.s Writer.c
    ../../../gnand/Lib/: n3290_GNAND.lib
    ../../../SIC/Lib/: N3290_SIC.lib
    ../../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../VPOST/Lib/: N3290_VPOST.lib
    ../../../gpio/lib/: n3290_gpio.lib
    ../../../Font/Lib/: N3290_Font_WVGA.lib N3290_Font_WQVGA.lib N3290_Font_QVGA.lib
target N32905_NandWriter_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_NandWriter_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32906_NandWriter_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_NandWriter_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_NandWriter_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_NandWriter_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_NandWriter_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_NandWriter_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_NandWriter_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_NandWriter_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
