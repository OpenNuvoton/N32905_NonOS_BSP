# Keil uVision project NVT Loader.uvproj, settings and files
target NAND_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVT_NAND_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_432x240__
  c include: ..\inc;..\..\AVI\Lib;..\..\VPOST\Lib;..\..\adc\lib;..\..\RTC\LIB;..\..\Font\Lib;..\..\gnand\Lib;..\..\gpio\lib;..\..\JPEG\LIB;..\..\kpi\lib;..\..\UDC\lib;..\..\NVTFAT\lib;..\..\SIC\Lib;..\..\SPU\lib;..\..\SYSLIB\Lib;..\..\USB_Core\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT Loader\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../NVT Loader/src/: avi.c heap.s main.c mass.c NVT_BatteryDect.c stack.s standalone.c vectors.s wb_init.s
    ../../AVI/Lib/: AviLib_320x240.lib AviLib_480x272.lib AviLib_640x480.lib AviLib_800x480.lib AviLib_800x600.lib ima_adpcm_codec.lib mp3lib.lib
    ../../VPOST/Lib/: W55FA93_VPOST_GW07000TNWV.lib W55FA93_VPOST_AMPIRE_800x480.lib W55FA93_VPOST_AMPIRE_800x600.lib W55FA93_VPOST_GW9406A.lib W55FA93_VPOST_GWGW8973.lib W55FA93_VPOST_TIANMA_TM022HDH31.lib W55FA93_VPOST_GWMTF9360A.lib W55FA93_VPOST_GWMTF9615A.lib W55FA93_VPOST_HannStar.lib W55FA93_VPOST_HannStar_800x480.lib W55FA93_VPOST_Sharp.lib W55FA93_VPOST_TV_VGA.lib W55FA93_VPOST_Wintek_WMF3324.lib W55FA93_VPOST_SITRONIX.lib W55FA93_VPOST_GIANTPLUS_GPM1006.lib W55FA93_VPOST_HIMAX_HX8352.lib W55FA93_VPOST_HIMAX_HX8352_START.lib
    ../../adc/lib/: W55FA93_adc_Poll.lib
    ../../RTC/LIB/: w55fa93_RTClib.lib
    ../../Font/Lib/: W55FA93_font_QVGA.lib W55FA93_font_SVGA.lib W55FA93_font_WSVGA.lib
    ../../gnand/Lib/: w55fa93_GNAND.lib
    ../../gpio/lib/: w55fa93_gpio.lib
    ../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../kpi/lib/: w55fa93_kpi.lib w55fa93_kpi_1x4.lib w55fa93_kpi_2x3.lib w55fa93_kpi_2x2.lib
    ../../UDC/lib/: w55fa93_MSC_NAND.lib w55fa93_MSC_SD_MP_PORT0.lib w55fa93_UDC.lib
    ../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../SIC/Lib/: W55FA93_SIC.lib
    ../../SPU/lib/: w55fa93_spu.lib
    ../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../NVT Loader/production/: EMU_ADC.c EMU_Draw.c EMU_Font.c EMU_KPD.c EMU_Memory.c EMU_NandFlash.c EMU_Production.c EMU_SdCard.c EMU_SPU.c EMU_USB_MassStorage.c EMU_USBH.c EMU_Vpost.c
target SD_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_GAINTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ __LCM_QVGA__ __ENABLE_SD_CARD_0__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT Loader\src\scat.scf
  link misc: --entry Reset_Go
