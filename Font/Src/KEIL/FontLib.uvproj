# Keil uVision project FontLib.uvproj, settings and files
target Font_QVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N3290_Font_QVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\Lib\.
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: Font.c
target Font_WQVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N3290_Font_WQVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\Lib\.
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Font_VGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N3290_Font_VGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\Lib\.
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_VGA_
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Font_WVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N3290_Font_WVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\Lib\.
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Font_SVGA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N3290_Font_SVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\Lib\.
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEMO_SVGA_
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
