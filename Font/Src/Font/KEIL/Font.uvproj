# Keil uVision project Font.uvproj, settings and files
target Font_WSVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA93_font_WSVGA (library)
  AfterMake: Font_WSVGA.bat
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WSVGA_
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: Font.c
target Font_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_font_SVGA (library)
  AfterMake: Font_WVGA.bat
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Font_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_font_QVGA (library)
  AfterMake: Font_QVGA.bat
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
