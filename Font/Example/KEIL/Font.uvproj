# Keil uVision project Font.uvproj, settings and files
target N32906_Font_U3DN_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_Font_U3DN_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\SYSLIB\Lib;..\..\..\gpio\lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\VPOST\lib;..\..\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Src
    ../: Font_demo.c DrawFont.c standalone.c wb_init.s
  group Lib
    ../../Lib/: N3290_Font_QVGA.lib N3290_Font_WQVGA.lib N3290_Font_VGA.lib N3290_Font_WVGA.lib
    ../../../GNAND/Lib/: n3290_GNAND.lib
    ../../../SIC/Lib/: N3290_SIC.lib
    ../../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../../VPOST/Lib/: N3290_VPOST_FW050TFT_800x480.lib N3290_VPOST_GIANTPLUS_GPM1006.lib
    ../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../gpio/lib/: n3290_gpio.lib
target N32905_Font_U3DN_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Font_U3DN_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32906_Font_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Font_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_Font_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Font_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_Font_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Font_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_Font_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Font_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_Font_VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Font_VGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_Font_VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Font_VGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_Font_VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Font_VGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_Font_VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Font_VGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_Font_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Font_480x272
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_Font_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Font_480x272
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_Font_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Font_480x272
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_Font_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Font_480x272
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_Font_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Font_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_Font_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Font_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_Font_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Font_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_Font_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Font_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
