# Keil uVision project demo.uvproj, settings and files
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../../: demo.c demo_AIC.c demo_Cache.c demo_CLK.c demo_HUART.c demo_Timer.c demo_UART.c demo_wakeup.c standalone.c wb_init.s
    ../../../Lib/: W55FA93_syslib.lib
    ../../../../gpio/lib/: w55fa93_gpio.lib
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=2 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
