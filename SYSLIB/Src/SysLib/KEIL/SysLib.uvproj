# Keil uVision project SysLib.uvproj, settings and files
target SYSLib (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N3290_SYSLib (library)
  AfterMake: Syslib.bat
  c flags: Optim=1 wLevel=2
  c define: __UVISION_VERSION
  c include: ..\..\..\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c wb_uart0.c wb_uartdev.c
target SYSLib_FreeRTOS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N3290_SYSLib_FreeRTOS (library)
  AfterMake: SYSLib_FreeRTOS.bat
  c flags: Optim=1 wLevel=2
  c define: __FreeRTOS__ __UVISION_VERSION
  c include: ..\..\..\Lib;..\..\..\..\FreeRTOS\Source\include;..\..\..\..\FreeRTOS\Source\portable\RVDS\ARM9_N329x;..\..\..\Src
  memory RVCT9: RAM 0xf8002000 size 0x8000
