# Keil uVision project w99683_demo.uvproj, settings and files
target N32906 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_USBH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c usb_keyboard.c W99683.c wb_init.s
    ../../../lib/: N3290_usbh.lib
    ../../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../../NVTFAT/lib/: N3290_nvtfat.lib
target N32905 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_USBH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_USBH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_USBH
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
