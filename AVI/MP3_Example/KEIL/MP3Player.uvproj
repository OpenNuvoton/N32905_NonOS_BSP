# Keil uVision project MP3Player.uvproj, settings and files
target N32906 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_MP3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Lib;..\..\..\VPOST\Lib;..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\Lib;..\..\..\JPEG\Lib;..\..\..\GNAND\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../: Demo_MP3.c standalone.c wb_init.s
    ../../Lib/: N3290_AVILib.lib IMA_ADPCM_Codec.lib MP3Lib.lib
    ../../../VPOST/Lib/: N3290_VPOST.lib
    ../../../SYSLIB/Lib/: N3290_SYSLib.lib
    ../../../SPU/Lib/: N3290_SPU.lib
    ../../../SIC/Lib/: N3290_SIC.lib
    ../../../NVTFAT/Lib/: N3290_NVTFAT.lib
    ../../../JPEG/Lib/: N3290_JPEGLib.lib
    ../../../GNAND/Lib/: N3290_GNAND.lib
target N32905 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_MP3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_MP3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_MP3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
