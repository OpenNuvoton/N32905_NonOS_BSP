# Keil uVision project kpi.uvproj, settings and files
target Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA93_KPI (library)
  AfterMake: Release.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_FA93_2X3_KPI
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: libkpi.c
target KPI_2x3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_KPI_2x3 (library)
  AfterMake: KPI_2x3.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_FA93_2X3_KPI
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target KPI_2x2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_KPI_2x2 (library)
  AfterMake: KPI_2x2.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_FA93_2X2_KPI
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target KPI_1x4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_KPI_1x4 (library)
  AfterMake: KPI_1x4.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_FA93_1X4_KPI
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target KPI_3x3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_KPI_3x3 (library)
  AfterMake: KPI_3x3.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_FA93_3X3_KPI
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
