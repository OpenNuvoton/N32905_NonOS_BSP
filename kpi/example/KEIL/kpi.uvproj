# Keil uVision project kpi.uvproj, settings and files
target nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: kpi
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: kpi.c standalone.c wb_init.s
    ../../lib/: w55fa93_kpi.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../gpio/lib/: w55fa93_gpio.lib
target block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: kpi
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
