# Keil uVision project SDLoader.uvproj, settings and files
target SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SDLoader\SdLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../SDLoader/: Depop.c heap.s sd.c SdLoader.c stack.s standalone.c vectors.s wb_config.c wb_init.s wb_uart.c
target SDLoader_192MHz_no_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDLoader_192MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __DISABLE_RTC__ __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SDLoader\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_S605-32_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDLoader_S605-32_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SDLoader\SdLoader.scf
  link misc: --entry Reset_Go
