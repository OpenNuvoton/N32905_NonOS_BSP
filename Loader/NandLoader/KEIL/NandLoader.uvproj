# Keil uVision project NandLoader.uvproj, settings and files
target N32906_NANDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32906.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../NandLoader/: Depop.c heap.s NandDrv.c NandLoader.c stack.s standalone.c vectors.s wb_config.c wb_init.s wb_uart.c
target N32905_NANDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader.scf
  link misc: --entry Reset_Go
target N32903_NANDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32903.scf
  link misc: --entry Reset_Go
target N32901_NANDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32901.scf
  link misc: --entry Reset_Go
target N32906_NANDLoader_192MHz_no_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_NANDLoader_192MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DISABLE_RTC__ __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32906.scf
  link misc: --entry Reset_Go
target N32905_NANDLoader_192MHz_no_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NANDLoader_192MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DISABLE_RTC__ __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader.scf
  link misc: --entry Reset_Go
target N32903_NANDLoader_192MHz_no_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NANDLoader_192MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DISABLE_RTC__ __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32903.scf
  link misc: --entry Reset_Go
target N32901_NANDLoader_192MHz_no_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NANDLoader_192MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DISABLE_RTC__ __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32901.scf
  link misc: --entry Reset_Go
target N32906_NANDLoader_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32906.scf
  link misc: --entry Reset_Go
target N32905_NANDLoader_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader.scf
  link misc: --entry Reset_Go
target N32903_NANDLoader_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32903.scf
  link misc: --entry Reset_Go
target N32901_NANDLoader_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32901.scf
  link misc: --entry Reset_Go
target N32906_NANDLoader_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32906.scf
  link misc: --entry Reset_Go
target N32905_NANDLoader_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader.scf
  link misc: --entry Reset_Go
target N32903_NANDLoader_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32903.scf
  link misc: --entry Reset_Go
target N32901_NANDLoader_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NandLoader\NandLoader_N32901.scf
  link misc: --entry Reset_Go
