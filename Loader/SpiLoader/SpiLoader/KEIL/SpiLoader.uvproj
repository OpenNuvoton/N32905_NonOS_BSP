# Keil uVision project SpiLoader.uvproj, settings and files
target N32905_HannSTar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SpiLoader_HS
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__
  c include: ..\inc;..\..\..\..\VPOST\Lib;..\..\..\..\gpio\lib;..\..\..\..\JPEG\LIB;..\..\..\..\kpi\lib;..\..\..\..\SPU\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\AVI\Lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../SpiLoader/src/: heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s
    ../../../../VPOST/Lib/: W55FA93_VPOST_AMPIRE_800x480.lib W55FA93_VPOST_AMPIRE_800x600.lib W55FA93_VPOST_GW9406A.lib W55FA93_VPOST_GWGW8973.lib W55FA93_VPOST_GWMTF9360A.lib W55FA93_VPOST_GWMTF9615A.lib W55FA93_VPOST_GIANTPLUS_GPM1006.lib W55FA93_VPOST_HannStar.lib W55FA93_VPOST_HannStar_800x480.lib W55FA93_VPOST_Sharp.lib W55FA93_VPOST_TV_VGA.lib W55FA93_VPOST_Wintek_WMF3324.lib
    ../../../../SPU/lib/: w55fa93_spu.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
target N32903_HannSTar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_HS
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_HannSTar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_HS
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_SHARP
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_SHARP
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_SHARP
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_WINTEK
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_WINTEK
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_WINTEK
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_AP_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_AP_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_AP_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW9406A_320x240
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW9406A_320x240
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW9406A_320x240
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GWMF9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GWMF9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GWMF9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GWMF9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GWMF9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GWMF9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW9615_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW9615_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GW9615_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GPM1006_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GPM1006_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_GPM1006_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32905_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32903_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat_N32901.scf
  link misc: --entry Reset_Go
