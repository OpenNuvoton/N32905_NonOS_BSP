# Keil uVision project SpiLoader_Security_gzip.uvproj, settings and files
target N32906_HannStar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_HannStar_D043I9W1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__ __Security__ N32906=1
  c include: ..\..\SpiLoader_gzip\inc;..\..\..\..\VPOST\Lib;..\..\..\..\gpio\lib;..\..\..\..\JPEG\LIB;..\..\..\..\kpi\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\SPU\lib;..\..\..\..\AVI\Lib;..\..\SpiLoader_gzip\src\ziplib;..\..\..\..\SPI\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../SpiLoader_gzip/src/: cmd_bootm.c heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s
    ../../../../VPOST/Lib/: N3290_VPOST_AMPIRE_800x480.lib N3290_VPOST_AMPIRE_800x600.lib N3290_VPOST_GW9406A.lib N3290_VPOST_GWGW8973.lib N3290_VPOST_GWMTF9360A.lib N3290_VPOST_GWMTF9615A.lib N3290_VPOST_HannStar.lib N3290_VPOST_HannStar_800x480.lib N3290_VPOST_Sharp.lib N3290_VPOST_TV_VGA.lib N3290_VPOST_Wintek_WMF3324.lib N3290_VPOST_GIANTPLUS_GPM1006.lib
    ../../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../../SPU/lib/: n3290_spu.lib
    ../../SpiLoader_gzip/src/ziplib/: zlib.c
    ../src/: Rootkey.c
    ../../../../SPI/Lib/: n3290_Secureic.lib
target N32905_HannStar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_HannStar_D043I9W1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_HannStar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_HannStar_D043I9W1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_HannStar_D043I9W1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_HannStar_D043I9W1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_480x272__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Sharp_LQ035Q1DH02
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Sharp_LQ035Q1DH02
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Sharp_LQ035Q1DH02
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Sharp_LQ035Q1DH02 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Sharp_LQ035Q1DH02
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_TV (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_TV
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __TV__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Ampire_800x600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Ampire_800x600
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x600__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Wintek_WMF3324
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Wintek_WMF3324
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Wintek_WMF3324
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Wintek_WMF3324 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Wintek_WMF3324
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __DEMO_MC__ __LCM_QVGA__ __IXL_WINTEK__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_Ampire_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_Ampire_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Ampire_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_Ampire_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Ampire_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __DDR2__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_GW9406A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_GW9406A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_GW9406A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GW9406A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_GW9406A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_GWMT9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_GWMT9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_GWMT9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GWMT9360A (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_GWMT9360A
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_HannStar_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_HannStar_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_800x480__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_GWMT9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_GWMT9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_GWMT9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GWMT9360A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_GWMT9360A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_GW9615A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__ __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_GW9615A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__ __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_GW9615A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GW9615A_WIFI_VIN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_GW9615A_WIFI_VIN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __WIFI__ __GWMT9615A__ __LCM_480x272__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_GIANTPLUS_GPM1006
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ CONFIG_BZIP2 __Security__ N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_GIANTPLUS_GPM1006
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_GIANTPLUS_GPM1006
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_GIANTPLUS_GPM1006
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32906_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__  __Security__ CONFIG_BZIP2 N32906=1
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32906.scf
  link misc: --entry Reset_Go
target N32905_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__  __Security__ CONFIG_BZIP2
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32903_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__  __Security__ CONFIG_BZIP2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32903.scf
  link misc: --entry Reset_Go
target N32901_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__  __Security__ CONFIG_BZIP2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat_N32901.scf
  link misc: --entry Reset_Go
