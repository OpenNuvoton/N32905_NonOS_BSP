# Keil uVision project kpi.uvproj, settings and files
target N32906_nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32906_nonblock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../: kpi.c standalone.c wb_init.s
    ../../lib/: n3290_kpi.lib
    ../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../gpio/lib/: n3290_gpio.lib
target N32905_nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_nonblock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_nonblock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_nonblock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32906_block
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32905_block
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_block
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_block
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
