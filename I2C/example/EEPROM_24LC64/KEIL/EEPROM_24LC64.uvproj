# Keil uVision project EEPROM_24LC64.uvproj, settings and files
target SingleTask (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: EEPROM_24LC64
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../../EEPROM_24LC64/: i2c_24LC64.c standalone.c wb_init.s
    ../../../Lib/: W55FA93_I2C.lib
    ../../../../SYSLIB/Lib/: W55FA93_SYSLib.lib
