# Keil uVision project SdWriter.uvproj, settings and files
target N32906_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib;..\..\..\gpio\lib;..\..\..\Font\Lib;..\..\..\gnand\Lib
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
  group Source Group 1
    ../: DrawFont.c ProcessIni.c ProcessOptionalIni.c standalone.c wb_init.s Writer.c
    ../../../SIC/Lib/: N3290_SIC.lib
    ../../../NVTFAT/lib/: N3290_nvtfat.lib
    ../../../SYSLIB/Lib/: N3290_syslib.lib
    ../../../VPOST/Lib/: N3290_VPOST.lib
    ../../../gpio/lib/: n3290_gpio.lib
    ../../../Font/Lib/: N3290_font_QVGA.lib N3290_Font_WVGA.lib N3290_Font_WQVGA.lib
target N32905_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32906_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32906_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32906
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32906\N32906.sct
  link misc: --entry 0
target N32905_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32905
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32905\N32905.sct
  link misc: --entry 0
target N32903_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
